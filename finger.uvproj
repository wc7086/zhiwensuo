# Keil uVision project finger.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: finger +hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\代码;.\oled
  group Source Group 1
    ./: main.c delay.c uart.c as608.c key.c pwr.c servo.c eeprom.c beep.c
    ./oled/: oled.c
